# Repository Danjovic/Atari5200PortEmulator

File readme.md:

# Atari 5200 Joystick Port Emulator

This device was designed to allow the development of Atari 5200 controllers whithout having the console

## BACKGROUND

Atari 5200 systems joysticks provides analog directional controller, two fire buttons, 10 numeric keys , Asterisk, Hash, Pause, Start and Reset keys.

The analog stick is read by measure the time a capacitor takes to charge, but contrary to contemporary systems it was done by hardware, specifically inside the POKEY chip.

The keypad is a conventional matrix but the reading is also done in hardware by the POKEY chip, that activates a pair of analog multiplexers (external to POKEY). One of the muxes route a GND return to ground to activate the lines of the matrix and the other mux connects one of the four rows of the matrix to a input (KR1) of the POKEY chip. A binary counter drives both muxes (2 bits for each mux) and whenever a LOW state is detected on the KR1 input the binary value of the counter is latched and a IRQ is generated (to the 6502). Only one key can be detected at a time.

Bottom fire button is also routed to KR2 input of POKEY Chip by a MUX (that is also driven by the binary counter). On the Atari Computers, this input is used to activate key modifiers (SHIFT, ALT, CONTROL). 

The TOP fire button is read (on the 5200) by the GTIA chip (not by the POKEY chip). 

Regarding interfacing, both Fire buttons are activated by a connection to Ground.

Atari 5200 provides a dedicated pin to supply voltage to the potentiometers that in turn charge the internal timing capacitors to measure the position of each axis of the stick. Such voltage is internally adjustable in the range of 4.2 to 6 Volts (approximately) to compensate for tolerances of potentiometer values and threshold voltage of the POKEY chip inputs (ViH). The voltage adjustment requires opening the console and fiddle with a trimpot. Such voltage  (named CAV or Vpot) can be turned on/off and that provides a way to differentiate a trackball controller from a joystick. 

Joysticks and paddles provides position by charging the timing capacitor with a fixed voltage through a variable resistance. Trackballs, on the other side provide a variable voltage across a fixed resistance, but unlike a traditional trackball (or a mouse) the 5200 trackballs do not provide relative movement, instead they provide a speed measurement. 
The faster you turn the ball in one direction the closer the measurement gets to a maximum or a minimum of the equivalent axis, for instance turn the ball up quickly should provide a measurement for the 5200 equivalent to the analog stick full upward.  A steady trackball should provide the equivalent of a joystick in its center position. 

Whenever the circuit of a trackball detects a fall in the CAV (Vpot) voltage it forces its outputs to a voltage close to 3 Volts (according with Atari technical documents). The timing measurements with such voltage will then be used by the game code as a reference for a "steady" trackball. Such measurements should be near the middle of the timing range.

A joystick, on the other hand will never charge the capacitor with CAV (Vpot) is turned off, and the measurements will return a value above the maximum expected for a joystick. 

The master clock for Pokey chip is the horizontal synchronization frequency. Timing is measured in terms of horizontal lines (64us each). Though the measurements can vary from 0 to 228 the the expected range for a controller is 10 to 190.

## CIRCUIT

The circuit is built around a PIC16F628A. This microcontroller was chosen over an AVR because of the dual analog comparator with adjustable voltage reference, that can be set to simulate different ViH threshold voltages of POKEY chip POT inputs. 
Each pot input has a timing capacitor of 47nf, a series 1k8 resistor, and an extra 1nf capacitor just like the POT inputs of the POKEY chip in Atari 5200. 

8 pins of the PIC are used to read the keypad. Each line is activated (held down) at a time and the rows are read one horizontal line time later (64us).

Top and Bottom buttons are read and all the values are printed at the serial port.

One of the pins of PORT B is connected directly to CAV.

## FIRMWARE

PIC microcontroller firmware is written in C language and can be compiled using [SDCC](http://sdcc.sourceforge.net/) / [GPUtils](https://gputils.sourceforge.io/). 

Output is sent through serial port. A serial terminal or emulator (like Putty) is necessary. The terminal configuration parameters are 9600 8-N-1.

Picture below shows the output of the terminal. The firmware switches Cav (Vpot) to determine whether the device connected is a joystick or a trackball. Then the potentiometer values are shown, followed by the buttons and finally the key pressed on keypad.

## EAGLE design circuit/Atari 5200 Controller Port Emulator.brd

Parts:
C1, C3: 1n; C050-024X044
C2, C4: 47n; C050-024X044
C5, C6: 100n; C050-024X044
IC1: PIC16F628P; DIL18
R1, R2: 1k8; 0204/7
R3, R4, R5, R6, R7, R8, R9, R10, R12, R13: 470; 0204/7
R11: 47k; 0204/7
R14: 1k; 0204/7
SV1: SERIAL; MA06-1
SV2: PGM; MA06-1
X1: M15H

Connections:
+5V: C5.1, IC1.14 (VDD), R11.1, SV1.1, SV2.2, X1.12
B: R12.2, X1.13
BOT/VPP: IC1.4 (RA5/MCLR/VPP), R11.2, R12.1, SV2.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, IC1.5 (VSS), R14.2, SV1.2, SV2.3, X1.15
LF/RG: C1.1, R1.1, X1.10
LINE0: IC1.15 (RA6/OSC2/CLKOUT), R8.2
LINE1: IC1.3 (RA4/TOCKI/CMP2), R9.2
LINE2: IC1.2 (RA3/AN3/CMP1), R10.2
LINE3: IC1.16 (RA7/ASC1/CLKIN), R7.2
unnamed: R3.1, X1.5
unnamed: R4.1, X1.6
unnamed: R5.1, X1.7
unnamed: R6.1, X1.8
unnamed: R7.1, X1.4
unnamed: R8.1, X1.3
unnamed: R9.1, X1.2
unnamed: R10.1, X1.1
POTX: C2.1, IC1.18 (RA1/AN1), R1.2
POTY: C4.1, IC1.17 (RA0/AN0), R2.2
R0W0/PGC: IC1.12 (RB6/T1OSO/1ICKI/PGC), R5.2, SV2.5
ROW1: IC1.11 (RB5), R4.2
ROW2: IC1.10 (RB4/PGM), R3.2
ROW3/PGD: IC1.13 (RB7/T1OSI/PGD), R6.2, SV2.4
RXI: IC1.8 (RB2/TX/CK), SV1.3
T: R13.2, X1.14
TOP: IC1.9 (RB3/CCP1), R13.1
TXD: IC1.7 (RB1/RX/DT), SV1.4
UP/DW: C3.1, R2.1, X1.11
VPOT: C6.1, IC1.6 (RB0/INT), R14.1, X1.9

Notes on the sheet:
Danjovic 2020
Atari 5200 Controller Port Emulator

Board: 2 copper layers, 50.8 x 40.6 mm, 24 parts (0 on the bottom side), 29 nets.

## Code that names these connections

File firmware/main.c (part):

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   PIC16F628A
                   +--___--+                            
        VREF/RA2 --|1    18|-- RA1/AN1  POT_X                   
PIN1 ROW2    RA3 --|2    17|-- RA0/AN0  POT_Y                  
PIN2 ROW1    RA4 --|3    16|-- RA7 ROW3 PIN4                   
BOT_BTN MCLR/RA5 --|4    15|-- RA6 ROW0 PIN3                    
             GND --|5    14|-- VCC                            
CAV_CNTRL    RB0 --|6    13|-- RB7 LINE3 PIN8                     
    RXD   RX/RB1 --|7    12|-- RB6 LINE0 PIN7       
    TXD   TX/RB2 --|8    11|-- RB5 LINE1 PIN6
TOP_BTN      RB3 --|9    10|-- RB4 LINE2 PIN5
                   +-------+  
*/

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
#define delay5us()        do { __asm__("nop\n nop\n nop\n nop\n nop"); } while (0)

#define cavOff() do {TRISB0=1; RB0=0;} while (0)  // CAV OFF
#define cavOn()  do {RB0=1; TRISB0=0;} while (0)  // CAV ON

#define TRISLIN0 TRISA6
#define TRISLIN1 TRISA4
#define TRISLIN2 TRISA3
#define TRISLIN3 TRISA7

#define RLIN0 RA6
#define RLIN1 RA4
#define RLIN2 RA3
#define RLIN3 RA7

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
static uint8_t rows[4];
static uint8_t hline = 0; // 
static uint8_t potx=0,poty=0;
uint8_t frameCounter; 
 
///////////////////////////////////////////////////////////////////////////////////////////////////////////////
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
// Setup I/O pins
TRISA = 0xFF;  // All pins as inputs, initially
TRISB = (uint8_t) ~(_TRISB0);  // Pin RB0 (CAV_CNTRL) as output

// Turn on Pullups on port B
NOT_RBPU=0;
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//

  for (;;) {  // TODO check RXbuffer for new commands
    cavOff(); // TRISB0=1; RB0=0; // CAV OFF
	measurePotentimeters(); _delayms(2); // complete roughly 1 frame 
	measurePotentimeters(); _delayms(2); // do it again
    
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       _puts("[TrackBall]");	   
	}
	
    cavOn(); //RB0=1; TRISB0=0; // CAV ON
    
    for (frameCounter = 4 ; frameCounter > 0 ; frameCounter--) {
        measurePotentimeters(); 
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	}
	
	// Hold capacitors on discharge
	TRISA0=0; RA0=0;
	TRISA1=0; RA1=0;
}

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
## Commit log

2020-02-04 Upload files to server
2020-02-09 Keyboard scan OK, buttons OK, Pot reading works but need validation
2020-02-09 Added pulldown resistor and filter capacitor on Vpot (Cav) line
2020-02-09 Upload files
2020-02-09 First release
2020-02-09 Updated images
2020-02-09 First working release
2020-02-19 Corrected TXD/RXD connections to RX232 module header
2020-02-23 Updated schematics
2020-02-29 Working version, updated schematics
2021-03-21 Trackball detection takes 2 frames, just like 5200 software

Notices in the files:
firmware/main.c:
This program is free software: you can redistribute it and/or modify
it under the terms of the GNU General Public License as published by
the Free Software Foundation, either version 3 of the License, or
(at your option) any later version.
